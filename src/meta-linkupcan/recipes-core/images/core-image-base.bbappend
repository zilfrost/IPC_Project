IMAGE_INSTALL:append = " can0-setup"
